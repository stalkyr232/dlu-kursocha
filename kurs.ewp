# IAR project kurs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CMSIS; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\include; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable\IAR; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable\IAR\ARM_CM4F; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\wrapper; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\wrapper\FreeRtos; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable\Common; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware\Registers; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware\Registers\STM32F411; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\Common; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware\InterruptHandler; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware\Registers\CortexM4; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CortexLib\AbstractHardware\Registers\CortexM4\FieldValues; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Applications; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Applications\Parameters; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Thread; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Hardware; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Hardware\ADC; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Hardware\DMA
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\CMSIS; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\include; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable\IAR; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable\IAR\ARM_CM4F; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\wrapper; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\wrapper\FreeRtos; F:\Github\Kolodiy\KURS_RABOTA\dlu-kursocha\Rtos\FreeRtos\portable\Common
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp StartUp.cpp
  group Applications
    Applications/: IDataSource.h
  group Applications/Parameters
    Applications/Parameters/: Filter.h Frequency.h IMeasureParameter.h Voltage.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h core_cm33.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f411xe.h stm32f4xx.h system_stm32f4xx.h
  group Hardware/ADC
    Hardware/ADC/: ADC.cpp ADC.h
  group Hardware/DMA
    Hardware/DMA/: DMA.h
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/include
    Rtos/FreeRtos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Thread
    Thread/: Generator_Task.cpp Generator_Task.h
